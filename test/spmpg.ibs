| IBIS file spmpg.ibs to test Series Pin Mapping implementation
| Apt Software Avenues Pvt Ltd
[IBIS ver]   3.0
[File name]   spmpg.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component spmpg
[Component]   spmpgtest
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
2   t2   m2
3   t3   m3
4   t4   m4
5   t5   NC
| ... test boundary conditions
[Series Pin Mapping]
[Series Pin Mapping] pin_2
5
[Series Pin Mapping] pin_2 model_name
5 4
| ... test that the functional group is not allowed
| ... for 3 column input
[Series Pin Mapping] pin_2 model_name
5 4 m3 f1
| ... various tests
[Series Pin Mapping] pin_2 model_name function_table_group junk
| ... invalid pins
8 9 m3   f1
| ... pins 2 and 3 should not be series, series_switch
2 3 m1   f1
| ... model should be of type series or series switch
5 4 m2   f1
| ... function group must be specified for 4 columns
5 4 m3   f1
5 4 m3
| ... invalid models
5 4 NC   f1
5 4 NA   f1
5 4 GND   f1
5 4 POWER  f1
| ... check on lengths
t0123456789 t012456789 abcdefghijklmnopqrstuvw  abcdefghijklmnopqrstuvw
[Series Switch Groups]
On f1 f2 /
|   Model m1
[Model]   m1
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m1
|   Model m2
[Model]   m2
Model_type   Series
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m2
|   Model m3
[Model]   m3
Model_type   Series_switch
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
[On]
[R_series]	1	NA	NA
[Off]
[R_series]  1K  NA  NA
| End [Model] m3
|   Model m4
[Model]   m4
Model_type   Terminator
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m4
| End [Component] spmpgtest
| Models and submodels in the file (4): m1 (Input), m2 (Series), m3 (Series_switch), m4 (Terminator)
