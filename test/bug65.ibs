|********************* IBIS GOLDEN PARSER BUG REPORT FORM *********************
|INSTRUCTIONS
|To report a bug in the IBIS golden parser.  Please fill out the top part
|of the following form and send the complete form to ibischk-bug@vhdl.org.
|A list of reported bugs will be maintained on vhdl.org.
|PARSER VERSION NUMBER: 3.2.8
|PLATFORM (SPARC, HP700, PC, etc.): SUN
|OS AND VERSION:Solaris
|REPORTED BY: Bob Ross, Mentor Graphics (from Todd Andersen, Philips)
|DATE: 12/5/2001
|DESCRIPTION OF BUG:
|Even though BIRD72.3 dealt with expanding the Series MOSFET transistor
|to include PMOS and PMOS in parallel with NMOS devices for IBIS Version 4.0,
|the need currently exists to format such devices.  For some parallel and
|PMOS only devices, the starting current may be higher then the ending
|current in the table.  This currently produces an ERROR, and some parsers
|will not allow the device to be processed.  This BUG suggests changing the
|message to a WARNING.  The current report is shown below.
|Checking bug65.ibs for IBIS 3.2 Compatibility...
|WARNING (line   45) - Series_MOSFET Typical data is non-monotonic
|ERROR - Model seriesswitch: Series_MOSFET has Decreasing Current
|WARNING (line   57) - Series_MOSFET Typical data is non-monotonic
|INSERT IBIS FILE DEMONSTRATING THE BUG:
[IBIS Ver] 3.2
[File Name] bug65.ibs
[File Rev] 2.0
[Source] Taken from real part
[Date] Saturday 10/13/01 12:49:14 PM
[Component] Sample
[Manufacturer] Generic
[Package]
| variable   typ   min   max
R_pkg  .22ohms NA NA
L_pkg  6.345nH NA NA
C_pkg  .48pF NA NA
[Pin] signal_name  model_name  R_pin  L_pin C_pin
2 1A1 NC .27 9.448n .626p
3 1A2 NC .261 8.878n .598p
[Series Pin Mapping]   pin_2   model_name   function_table_group
2 3 seriesswitch
[Model]   seriesswitch
Model_type   Series
|  variable   typ   min   max
C_comp   0.000pF  NA  NA
| variable typ   min   max
[Voltage Range] 3.30V NA NA
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| Models and submodels in the file (1): seriesswitch (Series)
