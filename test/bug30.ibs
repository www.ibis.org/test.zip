| IBIS file pmpg.ibs to test Series Pin Mapping implementation
| Apt Software Avenues Pvt Ltd
[IBIS ver]   2.1
[File name]   bug30.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component pmpg
[Component]   pmpgtest
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
2   t2   m2
3   t3   NC
4   t4   POWER
5   t5   GND
6   t6   NC
7   t7   m2
8   t8   POWER
9   t9   GND
| ... missing pin mapping
10   t10   GND
[Pin Mapping] pulldown_ref pullup_ref  gnd_clamp_ref   power_clamp_ref
1 BUS1 BUS1 BUS1 BUS1
2 BUS1 BUS1 BUS1 BUS1
3 BUS1 BUS1 BUS1 BUS1
4 BUS1 BUS1 BUS1 BUS1
5 BUS1 BUS1 BUS1 BUS1
6 NC   NC   NC   NC
7 BUS2 BUS3 BUS4 BUS5
8 BUS6 NC
9 NC   BUS7
| ... missing pin
11 NC  NC
[Component]   c1
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
| ... no headers specified
[Pin Mapping]
1 NC NC
[Component]   c2
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
| ... incomplete header
[Pin Mapping] pulldown_ref
1 NC NC
[Component]   c3
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
| ... this should be OK
[Pin Mapping] pulldown_ref pullup_ref
1 NC NC
[Component]   c4
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
| ... this should be OK
[Pin Mapping] pulldown_ref pullup_ref gnd_clamp_ref power_clamp_ref
1 NC NC
[Component]   c5
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
| ... incomplete header
[Pin Mapping] pulldown_ref pullup_ref gnd_clamp_ref
1 NC NC
[Component]   c6
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
| ... incomplete header
[Pin Mapping] pulldown_ref pullup_ref
1 NC NC NC NC
[Component]   c7
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
| ... incomplete mapping
[Pin Mapping] pulldown_ref pulldown_ref gnd_clamp_ref power_clamp_ref
1 NC NC NC
|   Model m1
[Model]   m1
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m1
|   Model m2
[Model]   m2
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m2
| End [Component] pmpgtest
| Models and submodels in the file (2): m1 (Input), m2 (Input)
