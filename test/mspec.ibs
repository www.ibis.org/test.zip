| IBIS file mspec.ibs to test Mspec implementation
| Apt Software Avenues Pvt Ltd
[IBIS ver]   3.0
[File name]   mspec.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component mspectest
[Component]   mspectest
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
|   Model m1
[Model]   m1
Model_type   Input
|Vinl=	 .2
|Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Model Spec]
Vinh   3.5   3.15   3.85
Vinl   1.5   1.35   1.65
Vinh+   2.0   1.5   2.5
Vinh-   1.6   1.1   1.7
Vinl+   1.1   1.0   1.2
Vinl-   0.6   0.5   0.7
S_overshoot_high   5.5   5.9   5.0
S_overshoot_low   -0.5   -0.6   -0.5
D_overshoot_high   6.0   6.0   6.5
D_overshoot_low   -1.0   -1.0   -1.0
D_overshoot_time   20n   20n   20n
Pulse_high   3V   2.5V   3.5V
Pulse_low   0   0   0
Pulse_time   3n   2.5n   3.5n
| ... check warning on !( min <= typ <= max) || !(max <= typ <= min)
[Model Spec]
Vinh   3.0   3.15   3.85
Vinl   1.7   1.35   1.65
Vinh+   1.4   1.5   2.5
Vinh-   1.0   1.1   1.7
Vinl+   0.9   1.0   1.2
Vinl-   0.8   0.5   0.7
S_overshoot_high   4.5   6.0   5.0
S_overshoot_low   -0.6   -0.5   -0.5
D_overshoot_high   6.0   7.5   6.5
D_overshoot_low   -1.2   -1.0   -1.0
D_overshoot_time   26n   25n   20n
Pulse_high   4V   2.5V   3.5V
Pulse_low   0.8   0   0
Pulse_time   4n   2.5n   3.5n
| ... test boundary conditions
[Model Spec]
[Model Spec]
Vinh
Vinl
[Model Spec]
Vinh   3.5
Vinl   1.5
[Model Spec]
Vinh   3.5   3.15
Vinl   1.5   1.35
[Model Spec]
Vinh   3.5   3.15   3.85
Vinl   1.5   1.35   1.65
[Model Spec]
Vinh   NA   3.15   3.85
Vinl   NA   1.35   1.65
[Model Spec]
Vinh   3.5   NA   3.85
Vinl   1.5   NA   1.65
[Model Spec]
Vinh   3.5   3.15   NA
Vinl   1.5   1.35   NA
[Model Spec]
Vinh+
[Model Spec]
Vinh+   2.0
| ... test that there is a warning if any threshold parameter is missing
[Model Spec]
|Vinh+   2.0   NA   NA
Vinh-   1.6   NA   NA
Vinl+   1.1   NA   NA
Vinl-   0.6   NA   NA
[Model Spec]
Vinh+   2.0   NA   NA
|Vinh-   1.6   NA   NA
Vinl+   1.1   NA   NA
Vinl-   0.6   NA   NA
[Model Spec]
Vinh+   2.0   NA   NA
Vinh-   1.6   NA   NA
|Vinl+   1.1   NA   NA
Vinl-   0.6   NA   NA
[Model Spec]
Vinh+   2.0   NA   NA
Vinh-   1.6   NA   NA
Vinl+   1.1   NA   NA
|Vinl-   0.6   NA   NA
| ... test relationships among the threshold parameters
| ... these are OK
[Model Spec]
Vinh+   2.0   1.9   2.1
Vinh-   1.6   NA   NA
Vinl+   1.1   1.0   1.2
Vinl-   0.6   NA   NA
[Model Spec]
Vinh+   2.0   NA   NA
Vinh-   1.6   1.5   1.7
Vinl+   1.1   NA   NA
Vinl-   0.6   0.5   .7
| ... these are error conditions for typ, min and max cases
[Model Spec]
Vinh+   2.0   1.9   2.1
Vinh-   3.0   2.9   3.1
Vinl+   1.1   1.0   1.2
Vinl-   2.1   2.0   2.2
[Model Spec]
Vinh+   2.0   NA   NA
Vinh-   3.0   2.9   3.1
Vinl+   1.1   NA   NA
Vinl-   2.1   2.0   2.2
[Model Spec]
Vinh+   2.0   1.9   2.1
Vinh-   3.0   NA   NA
Vinl+   1.1   1.0   1.2
Vinl-   2.1   NA   NA
| ... these are error conditions for the min case
[Model Spec]
Vinh+   2.0   1.9   2.1
Vinh-   2.0   NA   NA
Vinl+   1.1   1.0   1.2
Vinl-   1.1   NA   NA
| ... these are error conditions for the max case
[Model Spec]
Vinh+   3.0   NA   NA
Vinh-   3.0   2.9   3.1
Vinl+   2.1   NA   NA
Vinl-   2.1   2.0   2.2
| ... test relationships among the overshoot parameters
| ... these should be OK
[Model Spec]
D_overshoot_high   6.0   5.5   6.5
D_overshoot_low   -1.0   -1.0   -1.0
| ... test for wrong sign
[Model Spec]
D_overshoot_high   -6.0   -5.5   -6.5
D_overshoot_low   1.0   1.0   1.0
| ... test that static overshoot and dynamic time are also specified
[Model Spec]
D_overshoot_high   6.0   5.5   6.5
D_overshoot_low   -1.0   -1.0   -1.0
S_overshoot_high
S_overshoot_low
D_overshoot_time
| ... these should be OK
[Model Spec]
S_overshoot_high   -5.0   -4.5   -5.5
S_overshoot_low   0.5   0   1.0
| ... test when orphan dynamic time specified
[Model Spec]
D_overshoot_time   -1n   -0.5n   -1.5n
| ... test if time is negative
[Model Spec]
D_overshoot_high   6.0   5.5   6.5
D_overshoot_low   -1.0   -1.0   -1.0
D_overshoot_time   -1n   -0.5n   -1.5n
Pulse_high   3V   2.5V   3.5V
Pulse_low   0   0   0
Pulse_time   -3n   -2.5n   -3.5n
| ... these should be OK
[Model Spec]
D_overshoot_high   6.0   5.5   6.5
D_overshoot_low   -1.0   -0.5   -1.5
S_overshoot_high   5.0   4.5   5.5
S_overshoot_low   -0.5   0   -1.0
D_overshoot_time   1n   0.5n   1.5n
| ... warning if abs(dynamic overshoot) is not more than abs(static overshoot)
[Model Spec]
D_overshoot_high   6.0   5.5   6.5
D_overshoot_low   -1.0   -0.5   -1.5
S_overshoot_high   6.0   5.5   6.5
S_overshoot_low   -1.0   -0.5   -1.5
D_overshoot_time   1n   0.5n   1.5n
| ... test boundary conditions on pulse
[Model Spec]
Pulse_high
Pulse_low
| ... check error if pulse time is not specified
[Model Spec]
Pulse_high   3V   2.5V   3.5V
Pulse_low   1V   .5V   1.5V
| ... check error if thresholds are not specified
[Model Spec]
Pulse_high   3V   2.5V   3.5V
Pulse_low   1V   .5V   1.5V
Pulse_time   1n   .5n   1.5n
| ... pulse high should be > Vinl and pulse low should be < vinh
[Model Spec]
Vinh   1V   .5V   1.5V
Vinl   3V   2.5V   3.5V
Vinl+   2V   2V   2V
Vinl-   2V   2V   2V
Pulse_high   3V   2.5V   3.5V
Pulse_low   1V   .5V   1.5V
Pulse_time   1n   .5n   1.5n
| ... pulse high should be > Vinh- and pulse low should be < vinl+
[Model Spec]
Vinl-   1V   .5V   1.5V
Vinl+   1V   .5V   1.5V
Vinh+   3V   2.5V   3.5V
Vinh-   3V   2.5V   3.5V
Pulse_high   3V   2.5V   3.5V
Pulse_low   1V   .5V   1.5V
Pulse_time   1n   .5n   1.5n
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
|   Model m2
[Model]   m2
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
| ... this should be OK since the model thresholds will be used
[Model Spec]
Pulse_high   3V   2.5V   3.5V
Pulse_low   1V   .5V   1.5V
Pulse_time   1n   .5n   1.5n
| ... this should give errors with respect to the model thresholds
[Model Spec]
Pulse_high   .2V   .2V   .2V
Pulse_low   4.2V   4.2V   4.2V
Pulse_time   1n   .5n   1.5n
| ... boundary condition on Vmeas
[Model Spec]
Vmeas
[Model Spec]
Vmeas   3   2.9   2.8
[Model Spec]
Vmeas   2   1   3
[Model Spec]
junk
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Component] mspectest
| Models and submodels in the file (2): m1 (Input), m2 (Input)
