[IBIS Ver]   2.1
[File Name]   bug8.ibs
[File Rev]   0.1
[Date]   January 22, 1997
[Source]   Bob Ross, Interconnectix
[Disclaimer]   Provided for modeling purposes only.
   Results are not guaranteed.
[Component]   TEST
[Manufacturer]   Test File
[Package]
| variable   typ   min   max
R_pkg   0.0m   NA   NA
L_pkg   0.0nH   NA   NA
C_pkg   0.0pF   NA   NA
[Pin]   signal_name   model_name   R_pin   L_pin   C_pin
nc   One_Pin   NC
gnd   One_Pin   GND
na   One_Pin   NC
power   One_Pin   POWER
| Models and submodels in the file (0): 
