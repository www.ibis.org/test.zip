|********************* IBIS GOLDEN PARSER BUG REPORT FORM *********************
|INSTRUCTIONS
|To report a bug in the IBIS golden parser.  Please fill out the top part
|of the following form and send the complete form to ibischk-bug@vhdl.org.
|A list of reported bugs will be maintained on vhdl.org.
|PARSER VERSION NUMBER: 3.2.8
|PLATFORM (SPARC, HP700, PC, etc.): PC
|OS AND VERSION: Windows 2000 Version 5
|REPORTED BY: Jim Bell, SiQual Inc.
|DATE: 1/17/02
|DESCRIPTION OF BUG: Truncation of long File_name generates new errors.
|When IBISCHK3 detects a File_name that is too long, the truncation of the
|file name down to the legal size often results in new errors being generated:
|	1.) "File name opened 'original_file_name.ibs' not the same as File_name
|'truncated_file_name'"
|	2.) "File_name 'truncated_file_name' must contain one period."
|Error number 1 is reported because the File_name truncation occurred before
|the two file names were checked for equality. This can be remedied by
|checking the file names for equality before testing for File_name length.
|Error number 2 is generated because IBISCHK3 truncates the File_name
|starting on the right moving towards the left, almost always deleting the
|'.ibs' extension in the process. It is important that IBISCHK3 preserve the
|.ibs extension in the File_name when attempting to truncate down to the
|legal number of characters. There are two choices for fixing this problem:
|	1.) Don't try to truncate the File_name (recommended). Report the error,
|but leave the File_name as is.
|	2.) Do a better job of truncating the File_name. Do two truncations,
|preserving the .ibs extension in between.
|The following is the report generated when the example file was checked
|with IBISCHK3 v3.2.8.
|IBISCHK3 V3.2.8
|Checking thisisaverylongfilename.ibs for IBIS 2.1 Compatibility...
|ERROR (line   10) - File_name string 'thisisaverylongfilename.ibs' is too
|long, truncating to 12 characters.
|ERROR (line   10) - File_name 'thisisaveryl' must contain one period.
|ERROR (line   10) - File name opened 'thisisaverylongfilename.ibs' not the
|same as File_name 'thisisaveryl'.
|Errors  : 3
|File Failed
|INSERT IBIS FILE DEMONSTRATING THE BUG:
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[IBIS Ver]   3.1
[File name]   thisisaverylongfilename.ibs
[File Rev]   1.0
[Component]   fud
[Manufacturer]   fud inc
[Package]
R_pkg   2m   1m   3m
L_pkg   0.9n   0.8n   1.0n
C_pkg   0.3p   0.2p   0.4p
[Pin] signal_name   model_name
1   a   data_i
2   b   data_i
[Model]   data_i
Model_type Input
Vinh=2.0
Vinl=0.8
C_comp   4.5p   NA   10p
[Temperature Range] 25   85   -40
[Voltage Range]   5.0   4.5   5.5
|  End data_i
| Models and submodels in the file (1): data_i (Input)
