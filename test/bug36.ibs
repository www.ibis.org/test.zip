| This file demonstrates a bug with Diff Pin Mapping, Pin Mapping and
| Series Pin Mapping sections when reserved words are used as Pin
| Numbers
[IBIS Ver]   3.2
[Comment Char]  |_char
[File Name]   bug36.ibs
[File Rev]   1.0
[Date]   June 17, 1999
[Source]   Put originator and the source of information here.  For
   example:
[Notes]   Use this section for any special notes related to the file.
[Disclaimer]   This information is for modeling purposes only, and is not
[Copyright]   Copyright 1997, XYZ Corp., All Rights Reserved
[Component]   dummy
[Manufacturer]  none
[Package]
| variable   typ   min   max
R_pkg   250.0m   225.0m   275.0m
L_pkg   15.0nH   12.0nH   18.0nH
C_pkg   18.0pF   15.0pF   20.0pF
[Pin]   signal_name   model_name
  nc   nc   POWER
  na   na   GND
  power  power   POWER
  gnd   gnd   GND
[Pin Mapping]  pulldown_ref   pullup_ref   gnd_clamp_ref  power_clamp_ref
nc   NC   PWRCLMP
na   GNDCLMP   NC
power   NC   PWRCLMP
gnd   GNDCLMP   NC
[Diff Pin]  inv_pin  vdiff  tdelay_typ tdelay_min tdelay_max
 nc   na   150mV   -1ns   0ns   -2ns
 power   gnd   0V   1ns   NA   NA
[Series Pin Mapping] pin_2 model_name
nc   na   Series
power   gnd   Series
[Model] Series
Model_type Series
C_comp   1n   NA   NA
[Voltage Range]   3   NA   NA
[R Series]   1   NA   NA
| Models and submodels in the file (1): Series (Series)
