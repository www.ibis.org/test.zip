[IBIS Ver]   3.1
[File Name]   bug44.ibs
[File Rev]   0.1
[Component]   TEST
[Manufacturer]   Test File
[Package]
| variable   typ   min   max
R_pkg   -1   50   100
L_pkg   0.0nH   NA   NA
C_pkg   0.0pF   NA   NA
[Pin]   signal_name   model_name   R_pin   L_pin   C_pin
1   One_Pin   NC   1000   3.0n   3.5p
| Models and submodels in the file (0): 
