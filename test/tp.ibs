| IBIS file tp.ibs to test Driver Schedule implementation
| Apt Software Avenues Pvt Ltd
[IBIS ver]   3.0
[File name]   tp.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]  [Notes]
[Disclaimer]
[Copyright]
|   Component tptest
[Component]   tptest
Si_location
Si_location	 die
Si_location  pin
Si_location  Die
Si_location  Pin
| ... extra arguments
Si_location  Die Pin
| ... test sub parameter case should match
si_location  Die
Timing_location
Timing_location	 die
Timing_location  pin
Timing_location  Die
Timing_location  Pin
| ... extra arguments
Timing_location  Die Pin
| ... test sub parameter case should match
timing_location  Die
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
|   Model m1
[Model]   m1
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m1
| End [Component] tptest
| Models and submodels in the file (1): m1 (Input)
