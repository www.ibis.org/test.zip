| IBIS file pkgbug.ibs
| Apt Software Avenues Pvt Ltd
| this file defines 3 package models
| the first tests for basic syntax
| the second tests for fork/endfork
| the third tests for compatibility with 2.1 if Number of sections is
| not defined
[IBIS ver]   3.1
[File name]   pkgtest.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component pkgtest
[Component]   pkgtest
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Package Model] pkg1
[Pin]  signal_name   model_name
1   t1   m1
[Define Package Model]   Test1
[Manufacturer]  Quality Semiconductors Ltd.
[OEM]   Acme Packaging Co.
[Description]   220-Pin Quad Ceramic Flat Pack
[Number Of Sections]   6
[Number Of Pins]   100
[Pin Numbers]
| ... test orphans
Fork
Endfork
Len=0/
Len = 0/
| ... valid pin names
Pin1
Fork Len=0/
Endfork Len=0/
Len
R
C
L
NC
POWER
GND
NA
| ... funny looking pin names allowed by the syntax. generate warnings
/
//
R/
C/
L/
Len/
Fork/
Endfork/
R=
C=
L=
Len=
Fork=
Endfork=
R=/
C=/
L=/
Fork=/
Endfork=/
| ... this should be OK
Pin2 Len = 0/ Len =1 R = 1 C= 1p L=1n /
| ... repeated params
Len = 1 R=1 C=1p L=1p Len =1 R=1 C=1p L=1n /
| ... check case
Len = 0 / len=1 r=1 c=1p l=1n /
| ... invalid token
Len = 0 / Len=0 abcd=2.1 /
| ... Len has to be specified
Len = 0 / R=1 C=1p L=1n /
| ... Len before R/L/C
Len = 0 / R=1 Len=1 C=1p L=1p / R=1 C=1p Len=1 L=1p / R=1 C=1p L=1p Len=1 /
| ... Number formats
Len = 0 / Len=0.12.12 R=-12 C=E12 L=1.2E2.3 /
| ... Missing /
Len =0 / Len=1 C=1p L=1n
| ... L and C must be specifed when Len != 0. missing =
Len= 1/Len 5/
| ... Missing section
Len = 0 //Len =1 C=1p L=1n/
| ... The section must be specified on the line containing the Pin
Pin3
Len=0/
[End Package Model]
| ... test for various fork conditions
[Define Package Model]   Test2
[Manufacturer]   Quality Semiconductors Ltd.
[OEM]   Acme Packaging Co.
[Description]   220-Pin Quad Ceramic Flat Pack
[Number Of Sections]   3
[Number Of Pins]   2
[Pin Numbers]
| ... this pin has 3 sections not counting the Fork sections
Pin1
Fork
  Len=0 /
| ... nested fork
  Fork
   Len=1 L=1n C=1p/
  Endfork
  Len=0/
Endfork
Len=1 C=1p L=1n /
Len=1 C=1p L=1n /
Len=1 C=1p L=1n /
| ... empty fork
  Fork
  Endfork
| ... orphan Endfork
Endfork
| ... unterminated Fork
Fork
Len=1 C=1p L=1n /
| ... this pin has two sections
Pin2 Len=0/ Len=1 C=1p L=1n /
Fork
[End Package Model]
| ... if Number of sections is not specified then revert to old syntax
| ... anything is allowed as a Pin Name
[Define Package Model]   Test3
[Manufacturer]   Quality Semiconductors Ltd.
[OEM]   Acme Packaging Co.
[Description]   220-Pin Quad Ceramic Flat Pack
[Number Of Pins]   8
[Pin Numbers]
Pin1 Len=0/
Pin2 Len=1 R=1 C=1p L=1n/
Pin3
Fork
  Len=0 /
Endfork
Pin4 Len=1 C=1p L=1n /
Len=1 C=1p L=1n /
[End Package Model]
|   Model m1
[Model]   m1
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m1
| End [Component] pkgtest
| Models and submodels in the file (1): m1 (Input)
