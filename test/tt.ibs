| IBIS file tt.ibs to test TTpower and TTgnd
| Apt Software Avenues Pvt Ltd
[IBIS ver]   3.0
[File name]   tt.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component tttest
[Component]   tttest
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
|   Model m1
[Model]   m1
Model_type   Output
C_comp   5.00pF   5.00pF   5.00pF
| ... test values < 0
[TTgnd]			-1n   -1n  -1n
[TTpower]		-1n   -1n  -1n
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
|   Model m2
[Model]   m2
Model_type   Output
C_comp   5.00pF   5.00pF   5.00pF
| ... test typ in between min and max
[TTgnd]			1n   .5n   .8n
[TTpower]		.1n   .8n   .5n
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| Models and submodels in the file (2): m1 (Output), m2 (Output)
