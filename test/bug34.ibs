[IBIS Ver]   3.1 | or 2.1 or 1.1
[File Name]   bug34.ibs
[File Rev]   0.1
[Component]   TEST
[Manufacturer]   Test File
[Package]
| variable   typ   min   max
R_pkg   0.0m   NA   NA
L_pkg   0.0nH   NA   NA
C_pkg   0.0pF   NA   NA
[Pin]   signal_name   model_name
1   One_Pin   NC
[Model]   no_tables
Model_type  Output
|   typ   min   max
C_comp   2.6000pF   NA   NA
[Voltage Range]   3.3000V   NA   NA
[Ramp]
|   typ   min   max
dV/dt_r   1/1ns   NA   NA
dV/dt_f   1/1ns   NA   NA
| Models and submodels in the file (1): no_tables (Output)
