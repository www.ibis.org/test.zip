[IBIS Ver]   2.1
[File Name]   bug27.ibs
[File Rev]   0.1
[Notes]
The line above should contain nothing but 80 spaces.
[Component]   TEST
[Manufacturer]   Test File
[Package]
| variable   typ   min   max
R_pkg   0.0m   NA   NA
L_pkg   0.0nH   NA   NA
C_pkg   0.0pF   NA   NA
[Pin]   signal_name   model_name
1   One_Pin   NC
| Models and submodels in the file (0): 
