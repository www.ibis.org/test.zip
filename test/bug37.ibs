| this file illustrates a bug with the parser. An error is generated for
| the Pin Mapping for Pins 19 and 20, which is not correct. Any
| unique entry should be specified with at least one
| pin whose model is either POWER or GND.
[IBIS Ver]   3.2
[Comment Char]  |_char
[File Name]   bug37.ibs
[File Rev]   1.0   | Used for .ibs file variations
[Date]   June 17, 1999   | The latest file revision date
[Source]   Put originator and the source of information here.  For
   example:
[Notes]   Use this section for any special notes related to the file.
[Disclaimer]   This information is for modeling purposes only, and is not
   guaranteed.   | May vary by component
[Copyright]   Copyright 1997, XYZ Corp., All Rights Reserved
[Component]   dummy
[Manufacturer]  none
[Package]
| variable   typ   min   max
R_pkg   250.0m   225.0m   275.0m
L_pkg   15.0nH   12.0nH   18.0nH
C_pkg   18.0pF   15.0pF   20.0pF
[Pin]   signal_name   model_name
  1   RAS0#   POWER
  2   RAS1#   POWER
  3   EN1#   POWER
  4   A0   POWER
  5   D0   POWER
  6   RD#   POWER
  7   WR#   POWER
  8   A1   POWER
  9   D1   POWER
 10   GND   GND
 11   RDY#   POWER
 12   GND   GND
 13   GND   GND
 14   GND   GND
 15   GND   GND
 16   GND   GND
 17   GND   GND
 18   Vcc3   POWER
 19   Vcc4   POWER
 20   GND   GND
[Pin Mapping]  pulldown_ref   pullup_ref   gnd_clamp_ref  power_clamp_ref
1   GNDBUS1   PWRBUS1   | Signal pins and their associated
2   GNDBUS2   PWRBUS2   | ground and power connections
3   GNDBUS1   PWRBUS1   GNDCLMP   PWRCLAMP
4   GNDBUS2   PWRBUS2   GNDCLMP   PWRCLAMP
5   GNDBUS2   PWRBUS2   NC   PWRCLAMP
6   GNDBUS2   PWRBUS2   GNDCLMP   NC
7   GNDBUS1   NC   | One set of ground connections.
8   GNDBUS1   NC   | NC indicates no connection to
9   GNDBUS1   NC   | power bus.
10   GNDBUS2   NC   | Second set of ground connections
11   GNDBUS2   NC
12   GNDBUS2   NC
13   NC   PWRBUS1   | One set of power connections.
14   NC   PWRBUS1   | NC indicates no connection to
15   NC   PWRBUS1   | ground bus.
16   NC   PWRBUS2   | Second set of power connections
17   NC   PWRBUS2
18   NC   PWRBUS2
19   GNDCLMP 		NC   | Additional power connections
20   NC   PWRCLMP   | for clamps
| Models and submodels in the file (0): 
