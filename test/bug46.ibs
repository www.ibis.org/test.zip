[IBIS Ver]   3.1
[File Name]   bug46.ibs
[File Rev]   0.1
[Component]   TEST
[Manufacturer]   Test File
[Package]
| variable   typ   min   max
R_pkg   250.0m   225.0m   275.0m
L_pkg   2.0nH   1.0nH   10.0pH
C_pkg   5.0pF   4.0pF   5.0pF
[Pin]   signal_name   model_name
1   One_Pin   NC
| Models and submodels in the file (0): 
