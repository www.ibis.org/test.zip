| BUG32 Tests - Bob Ross, Mentor Graphics
[IBIS ver]   3.1
[File name]   bug32.ibs
[File Rev]   0.0
[Date]   September 26, 1998
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component test1
|  Version 2.1 MATRIX FORMAT - PASSES
[Component]   test1
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   NC
2   t2   NC
3   t3   NC   | More pins than in matrix OK
4   t4   NC
[Package Model] Matrix
|   Component test2
|  Version 3.1 LINE FORMAT WITH MATRIX - PASSES BUT SHOULD FAIL
[Component]   test2
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   NC
2   t2   NC
[Package Model] Linemat
|   Component test3
|  Version 3.1 LINE FORMAT - FAILS BUT SHOULD PASS
[Component]   test3
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   NC
2   t2   NC
[Package Model] Line
|   Package Model Matrix
[Define Package Model]  Matrix
[Manufacturer]   None
[OEM]   None
[Description]   2 Pin Matrix
[Number of Pins]   2
[Pin Numbers]
1
2
[Model Data]
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[End Model Data]
[End Package Model]
|   Package Model Linemat
[Define Package Model]  Linemat
[Manufacturer]   None
[OEM]   None
[Description]   2 Pin Matrix and line
[Number of Sections]   1   | Added line
[Number of Pins]   2
[Pin Numbers]
1  Len=1 L=.01 C=.01/   | Transmission Line Elements Added
2  Len=0 R=1/
[Model Data]   | Matrix Data Should Cause Error
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[End Model Data]
[End Package Model]
|   Package Model Line
[Define Package Model]  Line
[Manufacturer]   None
[OEM]   None
[Description]   Lines Only
[Number of Sections]   1   | Added line
[Number of Pins]   2
[Pin Numbers]
1  Len=1 L=.01 C=.01/   | Transmission Line Elements Added
2  Len=0 R=1/
[End Package Model]   | [Model Data] Section Deleted
| Models and submodels in the file (0): 
