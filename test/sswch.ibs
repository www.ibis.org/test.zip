| IBIS file sswch.ibs to test Series Switch Group implementation
| Apt Software Avenues Pvt Ltd
[IBIS ver]   3.0
[File name]   sswch.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component sswchtest
[Component]   sswchtest
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
[Series Switch Groups]
| ... test for empty off
 Off
| ... test for case
 off
| ... test for empty on
 On
| ... test for case
 on
| ... test for illegal word
 a234
| ... test for long function group
 Off 1 abcdefghijklmnopqrstuvwxyz  /
| ... test for missing / in the end
| ... test for repeated group names
 On  1 2 3
   4 5 6
   4 5 6
| ... test if the previous continuation is handled correctly
| ... test for multiple series switch keywords
| ... test for use of "on" and "off" as function groups
[Series Switch Groups]
 Off 1 2 3 off
 On  1 2 3 on
 Off 3 4 5 /
|   Component sswchtest2
| ... test if multiple components are handled correctly
[Component]   sswchtest2
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
| ... test for extraneous data after the keyword
| ... test for reserved words
[Series Switch Groups] abcd
 Off 1 2 /
 On  3 4 /
 On  power gnd nc na /
| End [Component] sswchtest2
|   Model m1
[Model]   m1
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m1
| End [Component] sswchtest
| Models and submodels in the file (1): m1 (Input)
