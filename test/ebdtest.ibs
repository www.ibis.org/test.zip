| IBIS file ebdtest.ibs to test ibis reference from an .ebd file
| Apt Software Avenues Pvt Ltd
[IBIS ver]   3.0
[File name]   ebdtest.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component ebdtest1
[Component]   ebdtest1
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Package Model] pkg1
[Pin]  signal_name   model_name
Pin1   t1   m1
|   Model m1
[Model]   m1
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m1
| Models and submodels in the file (1): m1 (Input)
