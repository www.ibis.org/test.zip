| IBIS file series.ibs to test Series implementation
| Apt Software Avenues Pvt Ltd
[IBIS ver]   3.0
[File name]   series.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component seriestest
[Component]   seriestest
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
|   Model m1
| ... test various boundary conditions of series keywords
| ... for a Series model
[Model]   m1
Model_type   Series
C_comp   5.00pF   5.00pF   5.00pF
[On]
[Off]
[On] this is on
[R_series]
[L_series]
[Rl_series]
[C_series]
[Rc_series]
[Lc_series]
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[Off] this is off
[R_series]
[L_series]
[Rl_series]
[C_series]
[Rc_series]
[Lc_series]
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[On]
[R_series]	1		NA			NA
[L_series]	1n		NA			NA
[Rl_series]	.1		NA			NA
[C_series]	1p		NA			NA
[Rc_series]	.1		NA			NA
[Lc_series]	.1n		NA			NA
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[Off]
[R_series]	1		NA			NA
[L_series]	1n		NA			NA
[Rl_series]	.1		NA			NA
[C_series]	1p		NA			NA
[Rc_series]	.1		NA			NA
[Lc_series]	.1n		NA			NA
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[Model Spec]
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
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[Ramp]
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[Pulldown Reference]   0		0		0
[Pullup Reference]   5		5		5
[POWER Clamp Reference]		5		5		5
[GND Clamp Reference]		0		0		0
[Driver Schedule]
[TTgnd]   1n		NA		NA
[TTpower]   1n		NA		NA
|   Model m2
| ... test various boundary conditions of series keywords for a
| ... Series_switch model
[Model]   m2
Model_type   Series_switch
C_comp   5.00pF   5.00pF   5.00pF
[On]
[Off]
[On] this is on
[R_series]
[Rl_series]
[L_series]
[C_series]
[Rc_series]
[Lc_series]
[Off] this is off
[R_series]
[Rl_series]
[L_series]
[C_series]
[Rc_series]
[Lc_series]
[On]
[R_series]	1		NA			NA
[L_series]	1n		NA			NA
[Rl_series]	.1		NA			NA
[C_series]	1p		NA			NA
[Rc_series]	.1		NA			NA
[Lc_series]	.1n		NA			NA
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[Off]
[R_series]	1		NA			NA
[L_series]	1n		NA			NA
[Rl_series]	.1		NA			NA
[C_series]	1p		NA			NA
[Rc_series]	.1		NA			NA
[Lc_series]	.1n		NA			NA
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[Model Spec]
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
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[Ramp]
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[Pulldown Reference]   0		0		0
[Pullup Reference]   5		5		5
[POWER Clamp Reference]		5		5		5
[GND Clamp Reference]		0		0		0
[Driver Schedule]
[TTgnd]   1n		NA		NA
[TTpower]   1n		NA		NA
| End [Model] m2
|   Model m3
| ... this will test for the condition where series keywords are specified
| for a model other than Series or Series_switch
[Model]   m3
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[On]
[Off]
[On]
[R_series]
[L_series]
[C_series]
[Off]
[R_series]
[L_series]
[C_series]
[On]
[R_series]	1		NA			NA
[L_series]	1n		NA			NA
[Rl_series]	.1		NA			NA
[C_series]	1p		NA			NA
[Rc_series]	.1		NA			NA
[Lc_series]	.1n		NA			NA
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[Off]
[R_series]	1		NA			NA
[L_series]	1n		NA			NA
[Rl_series]	.1		NA			NA
[C_series]	1p		NA			NA
[Rc_series]	.1		NA			NA
[Lc_series]	.1n		NA			NA
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[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m3
|   Model m4
| ... this will test for the condition where L_series and C_series are
| not specified for a Series_switch model but Rl, Rc and Lc are specified
[Model]   m4
Model_type   Series_switch
C_comp   5.00pF   5.00pF   5.00pF
[On]
[R_series]	1		NA			NA
[Rl_series]	.1		NA			NA
[Rc_series]	.1		NA			NA
[Lc_series]	.1n		NA			NA
[Off]
[R_series]	1		NA			NA
[Rl_series]	.1		NA			NA
[Rc_series]	.1		NA			NA
[Lc_series]	.1n		NA			NA
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
|   Model m5
| ... this will test for the condition where L_series and C_series are
| not specified for a Series model but Rl, Rc and Lc are specified
[Model]   m5
Model_type   Series
C_comp   5.00pF   5.00pF   5.00pF
[R_series]	1		NA			NA
[Rl_series]	.1		NA			NA
[Rc_series]	.1		NA			NA
[Lc_series]	.1n		NA			NA
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
|   Model m6
| ... this will test for the condition where no [On] or [Off] keyword is
| specified for a Series_switch model
[Model]   m6
Model_type   Series_switch
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
|   Model m7
| ... test for series MOSFET
[Model]   m7
Model_type   Series_switch
C_comp   5.00pF   5.00pF   5.00pF
[On]
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[Off]
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
|   Model m8
| ... test series current
[Model]   m8
Model_type   Series
C_comp   5.00pF   5.00pF   5.00pF
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[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| Models and submodels in the file (8): m1 (Series), m2 (Series_switch), m3 (Input), m4 (Series_switch), m5 (Series), m6 (Series_switch), m7 (Series_switch), m8 (Series)
