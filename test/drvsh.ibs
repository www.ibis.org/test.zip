| IBIS file drvsh.ibs to test Driver Schedule implementation
| Apt Software Avenues Pvt Ltd
[IBIS ver]   3.0
[File name]   drvsh.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component drvshtest
[Component]   drvshtest
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
2   t2   m2
3   t3   m3
4   t4   m10
|   Model m1
[Model]   m1
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Driver Schedule]
  m2   0.0ns   NA   0.0ns   NA
  m3   0.5ns   NA   0.5ns   NA
  m4   0.5n   1.5n   NA   NA
  m5   1.0n   NA   1.5n   NA
  m6   NA   NA   1.5n   2.0n
  m7   NA   1.0n   NA   0.5n
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m1
|   Model m2
| checks for recursive driver schedule specification
[Model]   m2
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Driver Schedule]
  m2   0.0ns   NA   0.0ns   NA
  m3   0.5ns   NA   0.5ns   NA
  m4   0.5n   1.5n   NA   NA
  m5   1.0n   NA   1.5n   NA
  m6   NA   NA   1.5n   2.0n
  m7   NA   1.0n   NA   0.5n
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m2
|   Model m3
[Model]   m3
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m3
|   Model m4
[Model]   m4
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m4
|   Model m10
| test all 16 combinations of delay specification
| only 4 of these combinations are OK
| all test for negative delay specification
[Model]   m10
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Driver Schedule]
  m3   NA   NA   NA   NA
  m3   NA   NA   NA   2.0n
  m3   NA   NA   0.5n   NA
  m3   NA   NA   0.5n   2.0n
  m3   NA   1.0n   NA   NA
  m3   NA   1.0n   NA   2.0n
  m3   NA   1.0n   0.5n   NA
  m3   NA   1.0n   0.5n   2.0n
  m3   0.0ns   NA   NA   NA
  m3   0.0ns   NA   NA   2.0ns
  m3   0.0ns   NA   0.5n   NA
  m3   0.0ns   NA   0.5n   2.0n
  m3   0.0ns   1.0n   NA   NA
  m3   0.0ns   1.0n   NA   2.0n
  m3   0.0ns   1.0n   0.5n   NA
  m3   0.0ns   1.0n   0.5n   2.0n
  m3   -0.1ns   -1.0n   -0.5n   -2.0n
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m10
|   Model m11
| test miscellaneous boundary conditions of delay specification
[Model]   m11
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Driver Schedule]
  m2
  m3   0.5ns
  m4   0.5n   1.5n
  m5   1.0n   NA   1.5n
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m11
|   Model m12
| test for an empty driver schedule
[Model]   m12
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Driver Schedule]
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m12
| End [Component] drvshtest
| Models and submodels in the file (7): m1 (Input), m2 (Input), m3 (Input), m4 (Input), m10 (Input), m11 (Input), m12 (Input)
