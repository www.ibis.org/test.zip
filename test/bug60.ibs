|********************* IBIS GOLDEN PARSER BUG REPORT FORM *********************
|DESCRIPTION OF BUG:
|The [Series Switch Groups] entries on each line are incorrectly order
|dependent.  They must follow the order of the series switch states listed
|under the function_table_group of the [Series Pin Mapping] keyword.
|Otherwise, incorrect Warning messages are issued.
|INSERT IBIS FILE DEMONSTRATING THE BUG:
|A Warning Message is issued for the following IBIS Model:
|IBISCHK3 V3.2.7
|Checking bug60.ibs for IBIS 3.2 Compatibility...
|WARNING - Component: bug60 Series Switch Function '1' is used but not defined
|WARNING - Component: bug60 Series Switch Function '3' is used but not defined
|WARNING - Component: bug60 Series Switch Function '4' is used but not defined
|Errors  : 0
|Warnings: 3
|File Passed
[IBIS Ver] 3.2
[File Name] bug60.ibs
[File Rev] 0.0
[Source]   Sample model
[Date]   August 23, 2001
[Notes]   The following information is for demo purposes only.
[Component] bug60
[Manufacturer] None
[Package]
| variable   typ   min   max
R_pkg   .177ohms   NA   NA
L_pkg   3.985nH   NA   NA
C_pkg   .405pF   NA   NA
[Pin]   signal_name   model_name   R_pin   L_pin   C_pin
1 VCC POWER .185 4.57n .42p
2 S1 IN1 .177 3.98n .42p
3 IA3 Term1 .174 3.79n .41p
4 IA2 Term1 .171 3.6n .37p
5 IA1 Term1 .171 3.6n .37p
6 IA0 Term1 .174 3.79n .41p
7 YA Term1 .177 3.98n .42p
8 GND GND .185 4.57n .42p
[Series Switch Groups]
| Function Group States
Off 1 2 3 4 /
On  2 1 3 4 /   | False Warning Messages when order is different
   |   from order in function_table_group below
| On  1 2 3 4 /  | No Warnings when this line above is replaced
[Series Pin Mapping]   pin_2   model_name   function_table_group
6  7  busswitch   1
5  7  busswitch   2
4  7  busswitch   3
3  7  busswitch   4
[Model]   busswitch
Model_type   Series_switch
|  variable   typ   min   max
C_comp   0.000pF  NA  NA
| variable typ   min   max
[Voltage Range] 5.000V NA NA
[On]
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[Off]
[R Series]   1M   1M   1M
[Model] Term1
Model_type Terminator
| variable   typ   min   max
C_comp   8.0pF  NA   NA
[Voltage Range] 5.000V NA NA
[Model] IN1
Model_type Input
Vinl = 800.0mV
Vinh = 2.000V
C_comp 4.000pF NA NA
| variable typ   min   max
[Voltage Range] 5.000V NA NA
| Models and submodels in the file (3): busswitch (Series_switch), Term1 (Terminator), IN1 (Input)
