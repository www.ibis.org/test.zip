| IBIS file to check for existence of non ascii characters (BIRD53)
| Apt Software Avenues Pvt Ltd
[IBIS ver]   3.0
[File name]   asciidos.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component mspectest
[Component]   mspectest
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
|   Model m1
[Model]   m1
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Voltage range]	 3   2.9   3.1
| Models and submodels in the file (1): m1 (Input)
