[IBIS Ver]   2.1
[Comment Char]  |_char
[File Name]   bug38with15char.ibs
[File Rev]   1.0
[Date]   May 3, 2000
[Component]   dummy
[Manufacturer]  none
[Package]
| variable   typ   min   max
R_pkg   250.0m   225.0m   275.0m
L_pkg   15.0nH   12.0nH   18.0nH
C_pkg   18.0pF   15.0pF   20.0pF
[Pin]   signal_name   model_name
  1   RAS0#   NC
| Models and submodels in the file (0): 
