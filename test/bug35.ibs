[IBIS ver]   3.0
[File name]   bug35.ibs
[File Rev]   0.0
[Date]   1/13/99
[Source]
[Notes]   This model is bogus.
[Disclaimer]
[Copyright]
|   Component mspectest
[Component]   mspectest
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   mCheck
|   Model mCheck
[Model]   mCheck
Model_type   Input
Vinl=  1.5
Vinh=  3.5
C_comp   5.00pF   5.00pF   5.00pF
| ... this should be OK since the model thresholds will be used
[Model Spec]
Pulse_high   3V   2.5V   3.5V
Pulse_low   1.2V   .5V   1.5V
Pulse_time   1.1n   .5n   1.5n
| **BUG**
| When the Vinh below is commented out error occurs
| From a glance at the source code, this effect will
| probably also occur within each "set" below when
| one row is commented out
Vinl  1.6 1.4 1.7
|Vinh  3.6 3.4 3.7
| FALLING
Vinl+ 3.62 3.61 3.63
Vinl- 1.62 1.61 1.63
| RISING
Vinh+ 3.42 3.41 3.43
Vinh- 1.42 1.41 1.43
S_overshoot_high 5.1 5.09 5.11
S_overshoot_low  -.1 -.11 -.09
D_overshoot_high 5.5 5.51 5.49
D_overshoot_low  -.2 -.21 -.19
D_overshoot_time .5n .4n .6n
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Component] mspectest
| Models and submodels in the file (1): mCheck (Input)
