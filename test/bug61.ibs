|********************* IBIS GOLDEN PARSER BUG REPORT FORM *********************
|INSTRUCTIONS
|To report a bug in the IBIS golden parser.  Please fill out the top part
|of the following form and send the complete form to ibischk-bug@vhdl.org.
|A list of reported bugs will be maintained on vhdl.org.
|PARSER VERSION NUMBER: 3.2.7
|PLATFORM (SPARC, HP700, PC, etc.): PC
|OS AND VERSION: Windows 2000 Version 5
|REPORTED BY: Jim Bell, SiQual Corp
|DATE: 10/12/01
|DESCRIPTION OF BUG:
|Under certain circumstances the parser fails to flag a missing [Series
|Switch Groups] section.
|INSERT IBIS FILE DEMONSTRATING THE BUG:
|   Example IBIS file of missing [Series Switch Groups]
|   section not caught in IBISCHK3 Version 3.2.7
[IBIS Ver]   3.2
[File name]   bug61.ibs
[File Rev]   1.0
[Component]   fud
[Manufacturer]   fud
[Package]
R_pkg   2m   1m   3m
L_pkg   0.9n   0.8n   1.0n
C_pkg   0.3p   0.2p   0.4p
[Pin] signal_name   model_name
1   a   data_i
2   b   data_i
|** In the [Series Pin Mapping] section below, notice that there is a
|** function table group called out, but no [Series Switch Groups] section
| in the file.
[Series Pin Mapping] pin_2 model_name   function_table_group
1   2   mosfet_switch   1
[Model]   data_i
Model_type Input
Vinh=2.0
Vinl=0.8
C_comp   4.5p   NA   10p
[Temperature Range] 25   85   -40
[Voltage Range]   5.0   4.5   5.5
|  End data_i
[Model]   mosfet_switch
Model_type Series_switch
C_comp   0.0p   NA   10p
[Temperature Range] 25   85   -40
[Voltage Range]   5.0   4.5   5.5
[On]
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[Off]
[R Series]   1G 1G 1G
| End mosfet_switch
| Models and submodels in the file (2): data_i (Input), mosfet_switch (Series_switch)
