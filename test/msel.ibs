| IBIS file msel.ibs to test Model Selector implementation
| Apt Software Avenues Pvt Ltd
[IBIS ver]   3.0
[File name]   msel.ibs
[File Rev]   0.0
[Date]   December, 26 1997
[Source]
[Notes]
[Disclaimer]
[Copyright]
|   Component mspectest
[Component]   mseltest
[Manufacturer]   None
[Package]
| variable   typ   min   max
R_pkg   2.00m   1.00m   3.00m
L_pkg   5.00nH   4.00nH   6.00nH
C_pkg   8.00pF   7.00pF   9.00pF
[Pin]  signal_name   model_name
1   t1   m1
| ... empty test
[Model Selector]
| ... redefinition test
[Model Selector] ms1
[Model Selector] ms1
| ... long name test
[Model Selector] ms012345678901234567890
| ... same as a model name test
[Model Selector] m1
| ... reserved word test
[Model Selector] POWER
| ... missing model descriptor test
[Model Selector] ms2
m1
| ... long model name test
[Model Selector] ms3
m012345678901234567890
| ... note we allow POWER, GND and NC as valid models
| ... in a model selector
[Model Selector] ms4
m1	this is model1
m2   this is model2
GND   this is model3
NA   this is model4
POWER   this is model5
NC   this is model6
gnd   this is model7
na   this is model8
power   this is model9
nc   this is model10
m2   this is model11
power   this is model12
|   Model m1
[Model]   m1
Model_type   Input
Vinl=	 .2
Vinh=	 4.2
C_comp   5.00pF   5.00pF   5.00pF
[Temperature Range]   50.00   100.00   0.00
[Voltage Range]   5.00V   4.50V   5.50V
| End [Model] m1
| End [Component] mseltest
| Models and submodels in the file (1): m1 (Input)
